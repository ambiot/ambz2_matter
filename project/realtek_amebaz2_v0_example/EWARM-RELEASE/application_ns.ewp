# IAR project application_ns.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; V8M_SECURE; CONFIG_BUILD_NONSECURE=1; ENABLE_SECCALL_PATCH; CONFIG_SYSTEM_TIME64=0
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\component\soc\realtek\8710c\fwlib\include; ..\..\..\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\component\soc\realtek\8710c\app\shell; ..\..\..\component\soc\realtek\8710c\app\stdio_port; ..\..\..\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8710C\secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8710C\non_secure; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\example; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\utilities; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\network; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\common\test; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\soc\realtek\8710c\misc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\soc\realtek\8710c\misc\driver; ..\..\..\component\soc\realtek\8710c\misc\os; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_test; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_fuzz_test; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_ota_central_client; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_datatrans; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_ancs; ..\..\..\component\common\application\mqtt\MQTTPacket\V5; ..\..\..\component\common\application\mqtt\MQTTPacket
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF; V8M_SECURE; CONFIG_BUILD_NONSECURE=1
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis; ..\..\..\component\os\os_dep\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C
  OBJCOPY.OOCOutputFile: application_ns.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$" "$PROJ_FNAME$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\postbuild_tz.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start
  ILINK.IlinkIcfFile: application_ns.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf=__wrap_sprintf; --redirect snprintf=__wrap_snprintf; --redirect vsnprintf=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --redirect hal_crypto_engine_init_platform=__wrap_hal_crypto_engine_init_platform; --redirect hal_pinmux_register=__wrap_hal_pinmux_register; --redirect hal_pinmux_unregister=__wrap_hal_pinmux_unregister; --redirect hal_xip_get_phy_addr=__wrap_hal_xip_get_phy_addr; --redirect hal_efuse_autoload_en=__wrap_hal_efuse_autoload_en; --redirect hal_efuse_hci_autoload_en=__wrap_hal_efuse_hci_autoload_en; --redirect hal_efuse_read=__wrap_hal_efuse_read; --redirect hal_efuse_write=__wrap_hal_efuse_write; --redirect hal_sec_efuse_read=__wrap_hal_sec_efuse_read; --redirect hal_sec_efuse_write=__wrap_hal_sec_efuse_write; --redirect hal_sec_key_get=__wrap_hal_sec_key_get; --redirect hal_sec_key_write=__wrap_hal_sec_key_write; --redirect hal_susec_key_get=__wrap_hal_susec_key_get; --redirect hal_susec_key_write=__wrap_hal_susec_key_write; --redirect hal_s_jtag_key_write=__wrap_hal_s_jtag_key_write; --redirect hal_ns_jtag_key_write=__wrap_hal_ns_jtag_key_write; --redirect hal_user_otp_get=__wrap_hal_user_otp_get; --redirect hal_user_otp_set=__wrap_hal_user_otp_set; --redirect hal_efuse_disable_sec_jtag=__wrap_hal_efuse_disable_sec_jtag; --redirect hal_efuse_disable_nonsec_jtag=__wrap_hal_efuse_disable_nonsec_jtag; --skip_dynamic_initialization; --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration amazon_freertos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; V8M_SECURE; CONFIG_BUILD_NONSECURE=1; ENABLE_SECCALL_PATCH; __IEEE_LITTLE_ENDIAN; __ORDER_LITTLE_ENDIAN__; __BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__; FILE=void; ENABLE_AMAZON_COMMON
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\component\soc\realtek\8710c\fwlib\include; ..\..\..\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\component\soc\realtek\8710c\app\shell; ..\..\..\component\soc\realtek\8710c\app\stdio_port; ..\..\..\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8710C\secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8710C\non_secure; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\example; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\utilities; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\network; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\common\test; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\soc\realtek\8710c\misc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\soc\realtek\8710c\misc\driver; ..\..\..\component\soc\realtek\8710c\misc\os; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\include; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\include\private; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\demos\realtek\ameba\common\config_files; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\demos\common\include; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\third_party\jsmn; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\third_party\tinycbor; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\ota\portable\realtek\ameba; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\third_party\pkcs11; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\FreeRTOS-Plus-TCP\include; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\IAR; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\FreeRTOS-Plus-TCP\source\protocols\include; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\third_party\unity\extras\fixture\src; ..\..\..\component\common\application\amazon\amazon-freertos-1.4.7\lib\third_party\unity\src; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_fuzz_test
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\postbuild_tz.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "Debug" "$TOOLKIT_DIR$"
  group @SRAM
    ../../../component/common/mbed/targets/hal/rtl8710c/: flash_api.c power_mode_api.c
    ../../../component/soc/realtek/8710c/misc/driver/: flash_api_ext.c
    ../../../component/common/file_system/fatfs/disk_if/src/: flash_fatfs.c
    ../../../component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_flash.c hal_spic.c
  group amazon/demos
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/realtek/ameba/common/application_code/: aws_main.c
  group amazon/demos/common/demo_runner
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/demo_runner/: aws_demo_runner.c
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/mqtt/: aws_subscribe_publish_loop.c
  group amazon/demos/common/devmode_key_provisioning
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group amazon/demos/common/greengrass_connectivity
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group amazon/demos/common/logging
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group amazon/demos/common/mqtt
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/mqtt/: aws_hello_world.c
  group amazon/demos/common/ota
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/ota/: aws_ota_update_demo.c
  group amazon/demos/common/shadow
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/shadow/: aws_shadow_lightbulb_on_off.c
  group amazon/demos/common/tcp
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/demos/common/tcp/: aws_simple_tcp_echo_server.c aws_tcp_echo_client_separate_tasks.c aws_tcp_echo_client_single_task.c
  group amazon/lib/bufferpool
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group amazon/lib/crypto
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/crypto/: aws_crypto.c
  group amazon/lib/greengrass
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group amazon/lib/mqtt
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group amazon/lib/ota
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/ota/: aws_ota_agent.c aws_ota_cbor.c
  group amazon/lib/ota/portable
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/ota/portable/realtek/ameba/: aws_ota_pal.c aws_ota_rtl8710b.c
  group amazon/lib/pkcs11/mbedtls
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
  group amazon/lib/pkcs11/portable
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/pkcs11/portable/realtek/ameba/: aws_pkcs11_pal.c
  group amazon/lib/secure_sockets
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/secure_sockets/portable/realtek/ameba/: aws_secure_sockets.c
  group amazon/lib/shadow
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/shadow/: aws_shadow.c aws_shadow_json.c
  group amazon/lib/third_party/jsmn
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/third_party/jsmn/: jsmn.c
  group amazon/lib/third_party/mbedtls
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group amazon/lib/third_party/tinycbor
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/third_party/tinycbor/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c
  group amazon/lib/third_party/unity
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/third_party/unity/src/: unity.c
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/third_party/unity/extras/fixture/src/: unity_fixture.c
  group amazon/lib/tls
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/tls/: aws_tls.c
  group amazon/lib/utils
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/utils/: aws_system_init.c
  group amazon/lib/wifi
    ../../../component/common/application/amazon/amazon-freertos-1.4.7/lib/wifi/portable/realtek/ameba/: aws_wifi.c
  group bluetooth/board
    ../../../component/common/bluetooth/realtek/sdk/board/amebaz2/src/hci/: bt_fwconfig.c bt_mp_patch.c bt_normal_patch.c hci_board.c hci_uart.c
    ../../../component/common/bluetooth/realtek/sdk/board/common/src/: cycle_queue.c
    ../../../component/common/bluetooth/realtek/sdk/board/amebaz2/src/data_uart/: data_uart.c
    ../../../component/common/bluetooth/realtek/sdk/board/common/os/freertos/: osif_freertos.c
    ../../../component/common/bluetooth/realtek/sdk/board/amebaz2/src/: platform_utils.c rtk_coex.c trace_uart.c
    ../../../component/common/bluetooth/realtek/sdk/board/amebaz2/src/vendor_cmd/: vendor_cmd.c
  group bluetooth/common
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/client/: ancs_client.c bas_client.c dfu_client.c gaps_client.c ota_client.c simple_ble_client.c
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/server/: bas.c dis.c hids.c hids_kb.c hids_rmc.c simple_ble_service.c
    ../../../component/common/bluetooth/realtek/sdk/board/common/src/: bt_uart_bridge.c hci_adapter.c hci_process.c trace_task.c
    ../../../component/common/file_system/ftl/: ftl.c ftl_crypto_plugin_iar.o
  group bluetooth/example
    ../../../component/common/bluetooth/realtek/sdk/: bt_example_entry.c
  group bluetooth/example/ble_central
    ../../../component/common/bluetooth/realtek/sdk/example/ble_central/: ble_central_app_main.c ble_central_app_task.c ble_central_at_cmd.c ble_central_client_app.c ble_central_link_mgr.c user_cmd.c
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/client/: gcs_client.c
    ../../../component/common/bluetooth/realtek/sdk/src/mcu/module/data_uart_cmd/: user_cmd_parse.c
  group bluetooth/example/ble_peripheral
    ../../../component/common/bluetooth/realtek/sdk/example/ble_peripheral/: app_task.c ble_app_main.c ble_peripheral_at_cmd.c peripheral_app.c
  group bluetooth/example/ble_scatternet
    ../../../component/common/bluetooth/realtek/sdk/example/ble_scatternet/: ble_scatternet_app.c ble_scatternet_app_main.c ble_scatternet_app_task.c ble_scatternet_link_mgr.c ble_scatternet_user_cmd.c
  group bluetooth/example/bt_airsync_config
    ../../../component/common/application/airsync/1.0.4/: airsync_ble_service.c check_endian.c epb.c epb_MmBp.c epb_WristBand.c wechat_airsync_protocol.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_airsync_config/: bt_airsync_config_app_main.c bt_airsync_config_app_task.c bt_airsync_config_peripheral_app.c
  group bluetooth/example/bt_ancs
    ../../../component/common/bluetooth/realtek/sdk/example/bt_ancs/: bt_ancs.c bt_ancs_app.c bt_ancs_app_task.c bt_ancs_main.c
  group bluetooth/example/bt_beacon
    ../../../component/common/bluetooth/realtek/sdk/example/bt_beacon/: bt_beacon_app.c bt_beacon_app_main.c bt_beacon_app_task.c
  group bluetooth/example/bt_config
    ../../../component/common/bluetooth/realtek/sdk/example/bt_config/: bt_config_app_main.c bt_config_app_task.c bt_config_peripheral_app.c bt_config_service.c bt_config_wifi.c
  group bluetooth/example/bt_datatrans
    ../../../component/common/bluetooth/realtek/sdk/example/bt_datatrans/: bt_datatrans_app_queue.c bt_datatrans_app_task.c bt_datatrans_at_cmd.c bt_datatrans_at_hci_cmd_process.c bt_datatrans_central_application.c bt_datatrans_client.c bt_datatrans_main.c bt_datatrans_module_param_config.c bt_datatrans_multilink_manager.c bt_datatrans_peripheral_application.c bt_datatrans_profile.c bt_datatrans_uart.c
  group bluetooth/example/bt_fuzz_test
    ../../../component/common/bluetooth/realtek/sdk/example/bt_fuzz_test/: bt_fuzz_test_app.c bt_fuzz_test_app_main.c bt_fuzz_test_app_task.c bt_fuzz_test_at_cmd.c bt_fuzz_test_link_mgr.c bt_fuzz_test_simple_ble_service.c bt_fuzz_test_user_cmd.c
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/server/: gls.c hrs.c ias.c
  group bluetooth/example/bt_mesh/mesh_common/cmd
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/cmd/: mesh_cmd.c mesh_data_uart.c mesh_user_cmd_parse.c test_cmd.c
  group bluetooth/example/bt_mesh/mesh_common/common
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/: bt_mesh_user_api.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: customer_dfu_service.c datatrans_app.c dfudep_service.c ping_app.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: delay_msg_rsp.c
  group bluetooth/example/bt_mesh/mesh_common/model
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/realtek/: datatrans_model.c ping_control.c tp_control.c
  group bluetooth/example/bt_mesh/mesh_common/profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/profile/: datatrans_service.c
  group bluetooth/example/bt_mesh/mesh_common/test
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_test/: bt_mesh_app_user_cmd_parse.c bt_mesh_datatrans_write_api.c bt_mesh_device_test.c bt_mesh_malloc_free.c bt_mesh_receive_response.c bt_mesh_test_result.c bt_mesh_timer_handler.c
  group bluetooth/example/bt_mesh/mesh_device
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/device/: bt_mesh_device_api.c
  group bluetooth/example/bt_mesh/mesh_device/bt_mesh_device_rtk_demo
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_device_rtk_demo/: example_bt_mesh_device_rtk_demo.c
  group bluetooth/example/bt_mesh/mesh_device/common
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/device/: device_idle_check.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: dfu_updater_app.c light_server_app.c scene_server_app.c scheduler_server_app.c time_server_app.c
  group bluetooth/example/bt_mesh/mesh_device/device
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/device/: bt_mesh_device_app_main.c bt_mesh_device_app_task.c device_app.c device_cmd.c
  group bluetooth/example/bt_mesh/mesh_device/device_multiple_profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_multiple_profile/device_multiple_profile/: bt_mesh_device_multiple_profile_app_main.c bt_mesh_device_multiple_profile_app_task.c device_multiple_profile_app.c device_multiple_profile_cmd.c
  group bluetooth/example/bt_mesh/mesh_device/lib
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/lib/amebaz2/: btmesh_dev.a
  group bluetooth/example/bt_mesh/mesh_device/model
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: delay_execution.c generic_on_off_server.c generic_transition_time.c health_server.c light_ctl_server.c light_ctl_setup_server.c light_ctl_temperature_server.c light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_server.c light_hsl_setup_server.c light_lightness_server.c light_lightness_setup_server.c light_xyl_server.c light_xyl_setup_server.c scene_server.c scene_setup_server.c scheduler_server.c scheduler_setup_server.c time_server.c time_setup_server.c
  group bluetooth/example/bt_mesh/mesh_device/profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/profile/: datatrans_server.c
  group bluetooth/example/bt_mesh/mesh_provisioner
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/provisioner/: bt_mesh_provisioner_api.c
  group bluetooth/example/bt_mesh/mesh_provisioner/bt_mesh_provisioner_rtk_demo
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_provisioner_rtk_demo/src/: bt_mesh_app_http_intf.c bt_mesh_app_lib_intf.c bt_mesh_app_list_intf.c bt_mesh_broadcast_demo.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_provisioner_rtk_demo/: example_bt_mesh_provisioner_rtk_demo.c
  group bluetooth/example/bt_mesh/mesh_provisioner/cmd
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/cmd/: client_cmd.c
  group bluetooth/example/bt_mesh/mesh_provisioner/common
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: dfu_distributor_app.c generic_client_app.c light_client_app.c rmt_prov_client_app.c
  group bluetooth/example/bt_mesh/mesh_provisioner/lib
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/lib/amebaz2/: btmesh_prov.a
  group bluetooth/example/bt_mesh/mesh_provisioner/model
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: blob_transfer_client.c configuration_client.c firmware_distribution_client.c firmware_update_client.c generic_battery_client.c generic_default_transition_time_client.c generic_level_client.c generic_location_client.c generic_on_off_client.c generic_power_level_client.c generic_power_on_off_client.c generic_property_client.c health_client.c light_ctl_client.c light_hsl_client.c light_lc_client.c light_lightness_client.c light_xyl_client.c private_beacon_client.c scene_client.c scheduler_client.c sensor_client.c time_client.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/realtek/: light_cwrgb_client.c
  group bluetooth/example/bt_mesh/mesh_provisioner/provisioner
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/provisioner/: bt_mesh_provisioner_app_main.c bt_mesh_provisioner_app_task.c provisioner_app.c provisioner_cmd.c
  group bluetooth/example/bt_mesh/mesh_provisioner/provisioner_multiple_profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_multiple_profile/provisioner_multiple_profile/: bt_mesh_provisioner_multiple_profile_app_main.c bt_mesh_provisioner_multiple_profile_app_task.c provisioner_multiple_profile_app.c provisioner_multiple_profile_cmd.c
  group bluetooth/example/bt_ota_central_client
    ../../../component/common/bluetooth/realtek/sdk/example/bt_ota_central_client/: bt_ota_central_client_app.c bt_ota_central_client_app_main.c bt_ota_central_client_app_task.c bt_ota_central_client_at_cmd.c bt_ota_central_client_link_mgr.c bt_ota_central_client_test_image.c insert_write.c
  group cmsis
    ../../../component/soc/realtek/8710c/cmsis/rtl8710c/source/ram_ns/: app_start.c system_rtl8710c_ns.c
    ../../../component/soc/realtek/8710c/misc/utilities/source/ram/: libc_wrap.c
    ../../../component/soc/realtek/8710c/cmsis/rtl8710c/source/ram/: mpu_config.c sys_irq.c
  group console
    ../../../component/common/api/at_cmd/: atcmd_bt.c atcmd_isp.c atcmd_lwip.c atcmd_media.c atcmd_mp.c atcmd_mp_ext2.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/soc/realtek/8710c/app/shell/: cmd_shell.c
    ../../../component/soc/realtek/8710c/misc/driver/: low_level_io.c rtl_console.c
  group lib
    ../../../component/soc/realtek/8710c/misc/bsp/lib/common/IAR/: application_s_import_lib.o lib_dct_ns.a lib_eap_ns.a lib_googlenest_ns.a lib_http_ns.a lib_p2p_ns.a lib_soc_ns.a lib_websocket_ns.a lib_wlan_ns.a lib_wps_ns.a
    ../../../component/common/bluetooth/realtek/sdk/board/amebaz2/lib/: btgap.a
    ../../../component/soc/realtek/8710c/fwlib/lib/lib/: hal_pmc.a
  group network/api
    ../../../component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../component/soc/realtek/8710c/misc/platform/: ota_8710c.c
    ../../../component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../component/common/utilities/: ssl_client.c ssl_client_ext.c ssl_client_ext_ns.c ssl_client_ns.c tcptest.c
  group network/app/mqtt
    ../../../component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../../component/common/application/mqtt/MQTTPacket/V5/: MQTTProperties.c MQTTV5Packet.c
  group network/coap
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../../../component/common/application/google/: google_tls.c
  group network/http
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../../../component/common/network/dhcp/: dhcps.c
    ../../../component/common/network/sntp/: sntp.c
  group network/lwip/api
    ../../../component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/core/ipv4
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/core/ipv6
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/netif
    ../../../component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group network/lwip/port
    ../../../component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../component/common/network/mDNS/: mDNSPlatform.c
  group network/ssl/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c debug.c entropy.c entropy_poll.c error.c gcm.c havege.c md.c md2.c md4.c md_wrap.c memory_buffer_alloc.c net_sockets.c padlock.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ripemd160.c sha256.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/ssl/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_func_stubs/: ssl_func_stubs.c
  group network/websocket
    ../../../component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group os
    ../../../component/os/freertos/: cmsis_os.c freertos_cb.c freertos_heap5_config.c freertos_heap_rtk.c freertos_pmu.c freertos_service.c
    ../../../component/os/os_dep/: device_lock.c osdep_service.c
  group os/freertos
    ../../../component/os/freertos/freertos_v10.2.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group os/freertos/portable
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8710C/non_secure/: port.c portasm.s
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8710c/: crypto_api.c dma_api.c efuse_api.c gpio_api.c gpio_irq_api.c i2c_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c reset_reason_api.c rtc_api.c serial_api.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/hal
    ../../../component/soc/realtek/8710c/fwlib/source/ram/: hal_gdma.c hal_gpio.c hal_misc.c hal_uart.c
    ../../../component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_i2c.c hal_pwm.c hal_sdio_dev.c hal_ssi.c
  group peripheral/wlan
    ../../../component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_rf_para_rtl8710c.c rtw_opt_skbuf.c
  group user
    ../src/: main.c
  group utilities
    ../../../component/common/utilities/: cJSON.c gb2unicode.c http_client.c xml.c
  group utilities/example
    ../../../component/common/example/amazon_awsiot/: example_amazon_awsiot.c
    ../../../component/common/example/amazon_freertos/: example_amazon_freertos.c
    ../../../component/common/example/bcast/: example_bcast.c
    ../../../component/common/example/cJSON/: example_cJSON.c
    ../../../component/common/example/coap/: example_coap.c
    ../../../component/common/example/coap_client/: example_coap_client.c
    ../../../component/common/example/coap_server/: example_coap_server.c
    ../../../component/common/example/dct/: example_dct.c
    ../../../component/common/example/eap/: example_eap.c
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/fatfs/: example_fatfs.c
    ../../../component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../component/common/example/googlenest/: example_google.c
    ../../../component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../component/common/example/http_client/: example_http_client.c
    ../../../component/common/example/http_download/: example_http_download.c
    ../../../component/common/example/httpc/: example_httpc.c
    ../../../component/common/example/httpd/: example_httpd.c
    ../../../component/common/example/mbedtls_ecdhe/: example_mbedtls_ecdhe.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mqtt/: example_mqtt.c
    ../../../component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../component/common/example/ota_http/: example_ota_http.c
    ../../../component/common/example/rarp/: example_rarp.c
    ../../../component/common/example/secure_boot/: example_secure_boot.c
    ../../../component/common/example/secure_storage/: example_secure_storage_ns.c
    ../../../component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/socket_tcp_trx/: example_socket_tcp_trx_1.c example_socket_tcp_trx_2.c
    ../../../component/common/example/ssl_download/: example_ssl_download.c
    ../../../component/common/example/ssl_server/: example_ssl_server.c
    ../../../component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../component/common/example/tickless_wifi_roaming/: example_tickless_wifi_roaming.c
    ../../../component/common/example/trust_zone/: example_trust_zone.c
    ../../../component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../component/common/example/websocket_client/: example_wsclient.c
    ../../../component/common/example/xml/: example_xml.c
  group utilities/FatFs/disk_if
    ../../../component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
    ../../../component/common/drivers/sdio/realtek/sdio_host/src/: sdio_combine.c
  group utilities/FatFs/fatfs_ext
    ../../../component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
  group utilities/FatFs/r0.10c
    ../../../component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
  group utilities/FatFs/r0.10c/option
    ../../../component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
